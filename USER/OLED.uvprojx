# Keil uVision project OLED.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\SYSTEM\usart;..\HARDWARE\OLED;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\TIMER;..\HARDWARE\ENCODER;..\HARDWARE\PID;..\HARDWARE\MOTOR;..\HARDWARE\SYSTICK;..\HARDWARE\DMA_ADC;..\LobotSerialServo;..\HARDWARE\OPENMV;..\HARDWARE\HMI;..\HARDWARE\LDM;..\FILTER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/SYSTICK/: systick.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/DMA_ADC/: dma_adc.c
    ../HARDWARE/OPENMV/: openmv.c
    ../HARDWARE/HMI/: hmi.c
    ../HARDWARE/LDM/: LDM.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c
  group README
    ../: README.TXT
  group LobotSerialServo
    ../LobotSerialServo/: bool.h LobotSerialServo.c Lobot_usart.c
  group FILTER
    ../FILTER/: T_D_Filter.c
